# Keil uVision project CapSense_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: CapSense_PSoC3lib (library)
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h CapSense.c CapSense.h CapSense_CSHL.c CapSense_CSHL.h CapSense_INT.c CapSense_Pins.c CapSense_Pins.h CapSense_PM.c CapSense_SMS_Wrapper.c CapSense_TunerHelper.c CapSense_TunerHelper.h LCD.c LCD.h LCD_PM.c CapSense_IntClock.c CapSense_IntClock.h CapSense_CompCH0.c CapSense_CompCH0.h CapSense_CompCH0_PM.c CapSense_AMuxCH0.c CapSense_AMuxCH0.h CapSense_IdacCH0.c CapSense_IdacCH0.h CapSense_IdacCH0_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h motorPWM.c motorPWM.h motorPWM_PM.c Pin_motor_for.c Pin_motor_for.h Pin_motor_for_aliases.h Clock_sensor.c Clock_sensor.h sensorInterrupt.c sensorInterrupt.h sensorTimer.c sensorTimer.h sensorTimer_PM.c timer_clock.c timer_clock.h Pin_sensor.c Pin_sensor.h Pin_sensor_aliases.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: CapSense_PSoC3lib (library)
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
